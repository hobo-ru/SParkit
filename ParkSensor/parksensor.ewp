# IAR project parksensor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG210F32 SiliconLaboratories EFM32TG210F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32TG210F32; SLAVE; nRAWSEND; PROTOCOL_C
  ICCARM.CCIncludePath2: ..\Libs\Device\EnergyMicro\EFM32TG\Include; ..\Libs\emlib\inc; ..\Libs\libtd1202\inc; ..\Libs\libtdrf\inc; inc; ..\Utils; ..\Libs\CMSIS\Include; ..\Libs\UNB; ..\Libs\RM2_HAL
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: parksensor.hex
  ILINK.IlinkOutputFile: parksensor.out
  ILINK.IlinkIcfFile: C:\ITS\AMR\Software\IAR project\SParkit\ParkSensor\parksensor.icf
  ILINK.IlinkAdditionalLibs: ..\Libs\libtdrf\libtdrf.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group inc
    inc/: defines.h
    ../Utils/: mag_sensor.h
  group libs/Device/inc
    ../Libs/Device/EnergyMicro/EFM32TG/Include/: efm32.h efm32tg108f16.h efm32tg108f32.h efm32tg108f4.h efm32tg108f8.h efm32tg110f16.h efm32tg110f32.h efm32tg110f4.h efm32tg110f8.h efm32tg210f16.h efm32tg210f32.h efm32tg210f8.h efm32tg222f16.h efm32tg222f32.h efm32tg222f8.h efm32tg225f16.h efm32tg225f32.h efm32tg225f8.h efm32tg230f16.h efm32tg230f32.h efm32tg230f8.h efm32tg232f16.h efm32tg232f32.h efm32tg232f8.h efm32tg822f16.h efm32tg822f32.h efm32tg822f8.h efm32tg825f16.h efm32tg825f32.h efm32tg825f8.h efm32tg840f16.h efm32tg840f32.h efm32tg840f8.h efm32tg842f16.h efm32tg842f32.h efm32tg842f8.h efm32tg_acmp.h efm32tg_adc.h efm32tg_aes.h efm32tg_af_pins.h efm32tg_af_ports.h efm32tg_calibrate.h efm32tg_cmu.h efm32tg_dac.h efm32tg_devinfo.h efm32tg_dma.h efm32tg_dma_ch.h efm32tg_dma_descriptor.h efm32tg_dmactrl.h efm32tg_dmareq.h efm32tg_emu.h efm32tg_gpio.h efm32tg_gpio_p.h efm32tg_i2c.h efm32tg_lcd.h efm32tg_lesense.h efm32tg_lesense_buf.h efm32tg_lesense_ch.h efm32tg_lesense_st.h efm32tg_letimer.h efm32tg_leuart.h efm32tg_msc.h efm32tg_pcnt.h efm32tg_prs.h efm32tg_prs_ch.h efm32tg_prs_signals.h efm32tg_rmu.h efm32tg_romtable.h efm32tg_rtc.h efm32tg_timer.h efm32tg_timer_cc.h efm32tg_usart.h efm32tg_vcmp.h efm32tg_wdog.h system_efm32tg.h
  group libs/Device/src
    ../Libs/Device/EnergyMicro/EFM32TG/Source/IAR/: startup_efm32tg.c startup_efm32tg.s
    ../Libs/Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group libs/emlib/inc
    ../Libs/emlib/inc/: em_acmp.h em_adc.h em_aes.h em_assert.h em_bitband.h em_burtc.h em_chip.h em_cmu.h em_common.h em_dac.h em_dbg.h em_dma.h em_ebi.h em_emu.h em_gpio.h em_i2c.h em_int.h em_lcd.h em_lesense.h em_letimer.h em_leuart.h em_mpu.h em_msc.h em_opamp.h em_part.h em_pcnt.h em_prs.h em_rmu.h em_rtc.h em_system.h em_timer.h em_usart.h em_vcmp.h em_version.h em_wdog.h
  group libs/emlib/src
    ../Libs/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group libs/libtd1202/inc
    ../Libs/libtd1202/inc/: at_parse.h td1202.h td_cmu.h td_flash.h td_gpio.h td_measure.h td_module.h td_printf.h td_rtc.h td_timer.h td_uart.h td_utils.h
  group libs/libtd1202/src
    ../Libs/libtd1202/src/: at_parse.c td_cmu.c td_flash.c td_gpio.c td_main.c td_measure.c td_printf.c td_rtc.c td_timer.c td_uart.c td_utils.c
  group libs/libtdrf/inc
    ../Libs/libtdrf/inc/: at_radio.h at_sigfox.h td_boot.h td_lan.h td_sigfox.h
  group libs/rm2_hal
    ../Libs/RM2_HAL/: rm2_hal.c rm2_hal.h
  group libs/unb
    ../Libs/UNB/: UNB.c UNB.h XTEA.c XTEA.h
  group libs/Utils/inc
    ../Utils/: commands.h crc16.h crc32.h flash.h Frame.h i2cEEPROM.h mag_stats.h packet.h Protocol.h rprintf.h timer.h uart.h uart_mesg.h utils.h xmodem2.h
  group libs/Utils/src
    ../Utils/: bootloader_inapp.c crc16.c crc32.c flash.c Frame.c i2cEEPROM.c mag_stats.c packet.c Protocol.c protocol_D.c rprintf.c time.c uart.c uart_mesg.c xmodem2.c
  group src
    ../Utils/: mag_sensor.c nwave_common.c
    src/: main.c
